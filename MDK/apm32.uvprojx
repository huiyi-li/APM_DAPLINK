# Keil uVision project apm32.uvprojx, settings and files
target Target 1 (6230000::V6.23::ARMCLANG)
  device: APM32F407ZE Geehy
  pack: Geehy.APM32F4xx_DFP.1.0.11
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: apm32
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=2 wLevel=3
  c define: APM32F40X;FX_INCLUDE_USER_DEFINE_FILE;LV_CONF_INCLUDE_SIMPLE;LV_KCONFIG_IGNORE;LV_LVGL_H_INCLUDE_SIMPLE
  c include: ..\Libraries\Device\Geehy\APM32F4xx\Include;..\Libraries\APM32F4xx_StdPeriphDriver\inc;..\bsp\inc;..\third\threadx\common\inc;..\third\threadx\ports\cortex_m4\ac6\inc;..\Libraries\CMSIS\Include;..\third\CherryUSB\core;..\third\CherryUSB\port\dwc2;..\third\CherryUSB\class\cdc;..\third\CherryUSB\class\hid;..\User;..\drivers\display;..\third\CherryUSB\common;..\third\CherryUSB\class\msc;..\third\CherryRB;..\third\DAP\Include;..\third\DAP\Config;..\third\filex\common\inc;..\third\filex\ports\cortex_m4\gnu\inc;..\third\filex\ports\generic\inc;..\;..\third\lvgl\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group FWLib
    ../Libraries/APM32F4xx_StdPeriphDriver/src/: apm32f4xx_adc.c apm32f4xx_can.c apm32f4xx_comp.c apm32f4xx_crc.c apm32f4xx_cryp.c apm32f4xx_cryp_aes.c apm32f4xx_cryp_des.c apm32f4xx_cryp_tdes.c apm32f4xx_dac.c apm32f4xx_dbgmcu.c apm32f4xx_dci.c apm32f4xx_dma.c apm32f4xx_dmc.c apm32f4xx_eint.c apm32f4xx_fmc.c apm32f4xx_gpio.c apm32f4xx_hash.c apm32f4xx_hash_md5.c apm32f4xx_hash_sha1.c apm32f4xx_i2c.c apm32f4xx_iwdt.c apm32f4xx_misc.c apm32f4xx_pmu.c apm32f4xx_qspi.c apm32f4xx_rcm.c apm32f4xx_rng.c apm32f4xx_rtc.c apm32f4xx_sdio.c apm32f4xx_smc.c apm32f4xx_spi.c apm32f4xx_syscfg.c apm32f4xx_tmr.c apm32f4xx_usart.c apm32f4xx_usb.c apm32f4xx_usb_device.c apm32f4xx_usb_host.c apm32f4xx_wwdt.c
  group StartUp
    ../Libraries/Device/Geehy/APM32F4xx/Source/arm/: startup_apm32f40x.s
  group User
    ../User/: apm32f4xx_int.c main.c system_apm32f4xx.c usb_config.h dap_main.c display_port.c display_port.h fx_spi_flash_driver.c filex_demo.c lvgl_port.c lvgl_demo.c
  group bsp
    ../bsp/src/: bsp_delay.c bsp_sdcard.c bsp_w25qxx.c bsp_printf.c bsp_sysclk.c bsp_uart1.c bsp_button.c bsp_cdc_uart.c bsp_led.c bsp_lcd_bus.c button.c
  group display
    ../drivers/display/: st7789.c st7789.h lcd_text.c
  group threadx/src
    ../third/threadx/common/src/: tx_block_allocate.c tx_block_pool_cleanup.c tx_block_pool_create.c tx_block_pool_delete.c tx_block_pool_info_get.c tx_block_pool_initialize.c tx_block_pool_performance_info_get.c tx_block_pool_performance_system_info_get.c tx_block_pool_prioritize.c tx_block_release.c tx_byte_allocate.c tx_byte_pool_cleanup.c tx_byte_pool_create.c tx_byte_pool_delete.c tx_byte_pool_info_get.c tx_byte_pool_initialize.c tx_byte_pool_performance_info_get.c tx_byte_pool_performance_system_info_get.c tx_byte_pool_prioritize.c tx_byte_pool_search.c tx_byte_release.c tx_event_flags_cleanup.c tx_event_flags_create.c tx_event_flags_delete.c tx_event_flags_get.c tx_event_flags_info_get.c tx_event_flags_initialize.c tx_event_flags_performance_info_get.c tx_event_flags_performance_system_info_get.c tx_event_flags_set.c tx_event_flags_set_notify.c tx_initialize_high_level.c tx_initialize_kernel_enter.c tx_initialize_kernel_setup.c tx_misra.c tx_mutex_cleanup.c tx_mutex_create.c tx_mutex_delete.c tx_mutex_get.c tx_mutex_info_get.c tx_mutex_initialize.c tx_mutex_performance_info_get.c tx_mutex_performance_system_info_get.c tx_mutex_prioritize.c tx_mutex_priority_change.c tx_mutex_put.c tx_queue_cleanup.c tx_queue_create.c tx_queue_delete.c tx_queue_flush.c tx_queue_front_send.c tx_queue_info_get.c tx_queue_initialize.c tx_queue_performance_info_get.c tx_queue_performance_system_info_get.c tx_queue_prioritize.c tx_queue_receive.c tx_queue_send.c tx_queue_send_notify.c tx_semaphore_ceiling_put.c tx_semaphore_cleanup.c tx_semaphore_create.c tx_semaphore_delete.c tx_semaphore_get.c tx_semaphore_info_get.c tx_semaphore_initialize.c tx_semaphore_performance_info_get.c tx_semaphore_performance_system_info_get.c tx_semaphore_prioritize.c tx_semaphore_put.c tx_semaphore_put_notify.c tx_thread_create.c tx_thread_delete.c tx_thread_entry_exit_notify.c tx_thread_identify.c tx_thread_info_get.c tx_thread_initialize.c tx_thread_performance_info_get.c tx_thread_performance_system_info_get.c tx_thread_preemption_change.c tx_thread_priority_change.c tx_thread_relinquish.c tx_thread_reset.c tx_thread_resume.c tx_thread_shell_entry.c tx_thread_sleep.c tx_thread_stack_analyze.c tx_thread_stack_error_handler.c tx_thread_stack_error_notify.c tx_thread_suspend.c tx_thread_system_preempt_check.c tx_thread_system_resume.c tx_thread_system_suspend.c tx_thread_terminate.c tx_thread_time_slice.c tx_thread_time_slice_change.c tx_thread_timeout.c tx_thread_wait_abort.c tx_time_get.c tx_time_set.c tx_timer_activate.c tx_timer_change.c tx_timer_create.c tx_timer_deactivate.c tx_timer_delete.c tx_timer_expiration_process.c tx_timer_info_get.c tx_timer_initialize.c tx_timer_performance_info_get.c tx_timer_performance_system_info_get.c tx_timer_system_activate.c tx_timer_system_deactivate.c tx_timer_thread_entry.c tx_trace_buffer_full_notify.c tx_trace_disable.c tx_trace_enable.c tx_trace_event_filter.c tx_trace_event_unfilter.c tx_trace_initialize.c tx_trace_interrupt_control.c tx_trace_isr_enter_insert.c tx_trace_isr_exit_insert.c tx_trace_object_register.c tx_trace_object_unregister.c tx_trace_user_event_insert.c txe_block_allocate.c txe_block_pool_create.c txe_block_pool_delete.c txe_block_pool_info_get.c txe_block_pool_prioritize.c txe_block_release.c txe_byte_allocate.c txe_byte_pool_create.c txe_byte_pool_delete.c txe_byte_pool_info_get.c txe_byte_pool_prioritize.c txe_byte_release.c txe_event_flags_create.c txe_event_flags_delete.c txe_event_flags_get.c txe_event_flags_info_get.c txe_event_flags_set.c txe_event_flags_set_notify.c txe_mutex_create.c txe_mutex_delete.c txe_mutex_get.c txe_mutex_info_get.c txe_mutex_prioritize.c txe_mutex_put.c txe_queue_create.c txe_queue_delete.c txe_queue_flush.c txe_queue_front_send.c txe_queue_info_get.c txe_queue_prioritize.c txe_queue_receive.c txe_queue_send.c txe_queue_send_notify.c txe_semaphore_ceiling_put.c txe_semaphore_create.c txe_semaphore_delete.c txe_semaphore_get.c txe_semaphore_info_get.c txe_semaphore_prioritize.c txe_semaphore_put.c txe_semaphore_put_notify.c txe_thread_create.c txe_thread_delete.c txe_thread_entry_exit_notify.c txe_thread_info_get.c txe_thread_preemption_change.c txe_thread_priority_change.c txe_thread_relinquish.c txe_thread_reset.c txe_thread_resume.c txe_thread_suspend.c txe_thread_terminate.c txe_thread_time_slice_change.c txe_thread_wait_abort.c txe_timer_activate.c txe_timer_change.c txe_timer_create.c txe_timer_deactivate.c txe_timer_delete.c txe_timer_info_get.c
  group threadx/port
    ../third/threadx/ports/cortex_m4/ac6/src/: tx_misra.S tx_thread_context_restore.S tx_thread_context_save.S tx_thread_interrupt_control.S tx_thread_interrupt_disable.S tx_thread_interrupt_restore.S tx_thread_schedule.S tx_thread_stack_build.S tx_thread_system_return.S tx_timer_interrupt.S
    ../third/threadx/ports/cortex_m4/ac6/: tx_initialize_low_level.S
  group cherryUsb/Core
    ../third/CherryUSB/core/: usbd_core.c
  group cherryUsb/Port
    ../third/CherryUSB/port/dwc2/: usb_dc_dwc2.c
    ../third/CherryUSB/osal/: usb_osal_threadx.c
    ../User/: user_usb_init.c
  group cherryUsb/Class
    ../third/CherryUSB/class/cdc/: usbd_cdc_acm.c
    ../third/CherryUSB/class/hid/: usbd_hid.c
    ../third/CherryUSB/class/msc/: usbd_msc.c
    ../third/CherryUSB/demo/: cdc_acm_template.c
  group cherryUsb/ringbuffer
    ../third/CherryRB/: chry_ringbuffer.c
  group lvgl/core
    ../third/lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
  group lvgl/display
    ../third/lvgl/src/display/: lv_display.c
  group lvgl/draw
    ../third/lvgl/src/draw/convert/helium/: lv_draw_buf_convert_helium.c
    ../third/lvgl/src/draw/convert/: lv_draw_buf_convert.c
    ../third/lvgl/src/draw/convert/neon/: lv_draw_buf_convert_neon.c
    ../third/lvgl/src/draw/dma2d/: lv_draw_dma2d.c lv_draw_dma2d_fill.c lv_draw_dma2d_img.c
    ../third/lvgl/src/draw/espressif/ppa/: lv_draw_ppa.c lv_draw_ppa_buf.c lv_draw_ppa_fill.c lv_draw_ppa_img.c
    ../third/lvgl/src/draw/eve/: lv_draw_eve.c lv_draw_eve_arc.c lv_draw_eve_fill.c lv_draw_eve_image.c lv_draw_eve_letter.c lv_draw_eve_line.c lv_draw_eve_ram_g.c lv_draw_eve_triangle.c lv_eve.c
    ../third/lvgl/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ../third/lvgl/src/draw/nema_gfx/: lv_draw_nema_gfx.c lv_draw_nema_gfx_arc.c lv_draw_nema_gfx_border.c lv_draw_nema_gfx_fill.c lv_draw_nema_gfx_img.c lv_draw_nema_gfx_label.c lv_draw_nema_gfx_layer.c lv_draw_nema_gfx_line.c lv_draw_nema_gfx_stm32_hal.c lv_draw_nema_gfx_triangle.c lv_draw_nema_gfx_utils.c lv_draw_nema_gfx_vector.c lv_nema_gfx_path.c
    ../third/lvgl/src/draw/nxp/g2d/: lv_draw_buf_g2d.c lv_draw_g2d.c lv_draw_g2d_fill.c lv_draw_g2d_img.c lv_g2d_buf_map.c lv_g2d_utils.c
    ../third/lvgl/src/draw/nxp/pxp/: lv_draw_buf_pxp.c lv_draw_pxp.c lv_draw_pxp_fill.c lv_draw_pxp_img.c lv_draw_pxp_layer.c lv_pxp_cfg.c lv_pxp_osa.c lv_pxp_utils.c
    ../third/lvgl/src/draw/opengles/: lv_draw_opengles.c
    ../third/lvgl/src/draw/renesas/dave2d/: lv_draw_dave2d.c lv_draw_dave2d_arc.c lv_draw_dave2d_border.c lv_draw_dave2d_fill.c lv_draw_dave2d_image.c lv_draw_dave2d_label.c lv_draw_dave2d_line.c lv_draw_dave2d_mask_rectangle.c lv_draw_dave2d_triangle.c lv_draw_dave2d_utils.c
    ../third/lvgl/src/draw/sdl/: lv_draw_sdl.c
    ../third/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
    ../third/lvgl/src/draw/sw/blend/neon/: lv_draw_sw_blend_neon_to_rgb565.c lv_draw_sw_blend_neon_to_rgb888.c
    ../third/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
    ../third/lvgl/src/draw/vg_lite/: lv_draw_buf_vg_lite.c lv_draw_vg_lite.c lv_draw_vg_lite_arc.c lv_draw_vg_lite_border.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_img.c lv_draw_vg_lite_label.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_line.c lv_draw_vg_lite_mask_rect.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_vector.c lv_vg_lite_decoder.c lv_vg_lite_grad.c lv_vg_lite_math.c lv_vg_lite_path.c lv_vg_lite_pending.c lv_vg_lite_stroke.c lv_vg_lite_utils.c
  group lvgl/drivers
    ../third/lvgl/src/drivers/display/drm/: lv_linux_drm.c lv_linux_drm_common.c lv_linux_drm_egl.c
    ../third/lvgl/src/drivers/display/fb/: lv_linux_fbdev.c
    ../third/lvgl/src/drivers/display/ft81x/: lv_ft81x.c
    ../third/lvgl/src/drivers/display/ili9341/: lv_ili9341.c
    ../third/lvgl/src/drivers/display/lcd/: lv_lcd_generic_mipi.c
    ../third/lvgl/src/drivers/display/nv3007/: lv_nv3007.c
    ../third/lvgl/src/drivers/display/nxp_elcdif/: lv_nxp_elcdif.c
    ../third/lvgl/src/drivers/display/renesas_glcdc/: lv_renesas_glcdc.c
    ../third/lvgl/src/drivers/display/st7735/: lv_st7735.c
    ../third/lvgl/src/drivers/display/st7789/: lv_st7789.c
    ../third/lvgl/src/drivers/display/st7796/: lv_st7796.c
    ../third/lvgl/src/drivers/display/st_ltdc/: lv_st_ltdc.c
    ../third/lvgl/src/drivers/draw/eve/: lv_draw_eve_display.c
    ../third/lvgl/src/drivers/evdev/: lv_evdev.c
    ../third/lvgl/src/drivers/libinput/: lv_libinput.c lv_xkb.c
    ../third/lvgl/src/drivers/nuttx/: lv_nuttx_cache.c lv_nuttx_entry.c lv_nuttx_fbdev.c lv_nuttx_image_cache.c lv_nuttx_lcd.c lv_nuttx_libuv.c lv_nuttx_mouse.c lv_nuttx_profiler.c lv_nuttx_touchscreen.c
    ../third/lvgl/src/drivers/opengles/assets/: lv_opengles_shader.c
    ../third/lvgl/src/drivers/opengles/glad/src/: egl.c gles2.c
    ../third/lvgl/src/drivers/opengles/: lv_opengles_debug.c lv_opengles_driver.c lv_opengles_egl.c lv_opengles_glfw.c lv_opengles_texture.c
    ../third/lvgl/src/drivers/opengles/opengl_shader/: lv_opengl_shader_manager.c lv_opengl_shader_program.c
    ../third/lvgl/src/drivers/qnx/: lv_qnx.c
    ../third/lvgl/src/drivers/sdl/: lv_sdl_keyboard.c lv_sdl_mouse.c lv_sdl_mousewheel.c lv_sdl_window.c
    ../third/lvgl/src/drivers/uefi/: lv_uefi_context.c lv_uefi_display.c lv_uefi_indev_keyboard.c lv_uefi_indev_pointer.c lv_uefi_indev_touch.c lv_uefi_private.c
    ../third/lvgl/src/drivers/wayland/: lv_wayland.c lv_wayland_smm.c lv_wl_cache.c lv_wl_dmabuf.c lv_wl_keyboard.c lv_wl_pointer.c lv_wl_pointer_axis.c lv_wl_seat.c lv_wl_shm.c lv_wl_touch.c lv_wl_window.c lv_wl_window_decorations.c lv_wl_xdg_shell.c
    ../third/lvgl/src/drivers/windows/: lv_windows_context.c lv_windows_display.c lv_windows_input.c
    ../third/lvgl/src/drivers/x11/: lv_x11_display.c lv_x11_input.c
  group lvgl/font
    ../third/lvgl/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
  group lvgl/indev
    ../third/lvgl/src/indev/: lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
  group lvgl/layouts
    ../third/lvgl/src/layouts/flex/: lv_flex.c
    ../third/lvgl/src/layouts/grid/: lv_grid.c
    ../third/lvgl/src/layouts/: lv_layout.c
  group lvgl/libs
    ../third/lvgl/src/libs/FT800-FT813/: EVE_commands.c EVE_supplemental.c
    ../third/lvgl/src/libs/barcode/: code128.c lv_barcode.c
    ../third/lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
    ../third/lvgl/src/libs/bmp/: lv_bmp.c
    ../third/lvgl/src/libs/expat/: xmlparse.c xmlrole.c xmltok.c xmltok_impl.c xmltok_ns.c
    ../third/lvgl/src/libs/ffmpeg/: lv_ffmpeg.c
    ../third/lvgl/src/libs/freetype/: lv_freetype.c lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_ftsystem.c
    ../third/lvgl/src/libs/frogfs/src/: decomp_raw.c frogfs.c
    ../third/lvgl/src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_frogfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_uefi.c lv_fs_win32.c
    ../third/lvgl/src/libs/gif/AnimatedGIF/src/: gif.c
    ../third/lvgl/src/libs/gif/: lv_gif.c
    ../third/lvgl/src/libs/gltf/gltf_view/assets/: chromatic.c lv_gltf_view_shader.c
    ../third/lvgl/src/libs/gltf/gltf_view/ibl/: lv_gltf_ibl_sampler.c
    ../third/lvgl/src/libs/gstreamer/: lv_gstreamer.c
    ../third/lvgl/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c
    ../third/lvgl/src/libs/libpng/: lv_libpng.c
    ../third/lvgl/src/libs/lodepng/: lodepng.c lv_lodepng.c
    ../third/lvgl/src/libs/lz4/: lz4.c
    ../third/lvgl/src/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../third/lvgl/src/libs/rle/: lv_rle.c
    ../third/lvgl/src/libs/rlottie/: lv_rlottie.c
    ../third/lvgl/src/libs/svg/: lv_svg.c lv_svg_decoder.c lv_svg_parser.c lv_svg_render.c lv_svg_token.c
    ../third/lvgl/src/libs/tiny_ttf/: lv_tiny_ttf.c
    ../third/lvgl/src/libs/tjpgd/: lv_tjpgd.c tjpgd.c
    ../third/lvgl/src/libs/vg_lite_driver/VGLiteKernel/: vg_lite_kernel.c
    ../third/lvgl/src/libs/vg_lite_driver/VGLite/: vg_lite.c vg_lite_image.c vg_lite_matrix.c vg_lite_path.c vg_lite_stroke.c
    ../third/lvgl/src/libs/vg_lite_driver/lv_vg_lite_hal/: lv_vg_lite_hal.c vg_lite_os.c
  group lvgl/lv_init.c
    ../third/lvgl/src/: lv_init.c
  group lvgl/misc
    ../third/lvgl/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
    ../third/lvgl/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../third/lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ../third/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_profiler_builtin.c lv_profiler_builtin_posix.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
  group lvgl/osal
    ../third/lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_linux.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_sdl2.c lv_windows.c
  group lvgl/others
    ../third/lvgl/src/others/file_explorer/: lv_file_explorer.c
    ../third/lvgl/src/others/font_manager/: lv_font_manager.c lv_font_manager_recycle.c
    ../third/lvgl/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../third/lvgl/src/others/gridnav/: lv_gridnav.c
    ../third/lvgl/src/others/ime/: lv_ime_pinyin.c
    ../third/lvgl/src/others/imgfont/: lv_imgfont.c
    ../third/lvgl/src/others/monkey/: lv_monkey.c
    ../third/lvgl/src/others/observer/: lv_observer.c
    ../third/lvgl/src/others/snapshot/: lv_snapshot.c
    ../third/lvgl/src/others/sysmon/: lv_sysmon.c
    ../third/lvgl/src/others/test/: lv_test_display.c lv_test_helpers.c lv_test_indev.c lv_test_indev_gesture.c lv_test_screenshot_compare.c
    ../third/lvgl/src/others/translation/: lv_translation.c
    ../third/lvgl/src/others/vg_lite_tvg/: vg_lite_matrix.c
    ../third/lvgl/src/others/xml/: lv_xml.c lv_xml_base_types.c lv_xml_component.c lv_xml_load.c lv_xml_parser.c lv_xml_style.c lv_xml_test.c lv_xml_translation.c lv_xml_update.c lv_xml_utils.c lv_xml_widget.c
    ../third/lvgl/src/others/xml/parsers/: lv_xml_arc_parser.c lv_xml_bar_parser.c lv_xml_button_parser.c lv_xml_buttonmatrix_parser.c lv_xml_calendar_parser.c lv_xml_canvas_parser.c lv_xml_chart_parser.c lv_xml_checkbox_parser.c lv_xml_dropdown_parser.c lv_xml_image_parser.c lv_xml_keyboard_parser.c lv_xml_label_parser.c lv_xml_obj_parser.c lv_xml_qrcode_parser.c lv_xml_roller_parser.c lv_xml_scale_parser.c lv_xml_slider_parser.c lv_xml_spangroup_parser.c lv_xml_spinbox_parser.c lv_xml_switch_parser.c lv_xml_table_parser.c lv_xml_tabview_parser.c lv_xml_textarea_parser.c
  group lvgl/stdlib
    ../third/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../third/lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../third/lvgl/src/stdlib/: lv_mem.c
    ../third/lvgl/src/stdlib/micropython/: lv_mem_core_micropython.c
    ../third/lvgl/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
    ../third/lvgl/src/stdlib/uefi/: lv_mem_core_uefi.c
  group lvgl/themes
    ../third/lvgl/src/themes/default/: lv_theme_default.c
    ../third/lvgl/src/themes/: lv_theme.c
    ../third/lvgl/src/themes/mono/: lv_theme_mono.c
    ../third/lvgl/src/themes/simple/: lv_theme_simple.c
  group lvgl/tick
    ../third/lvgl/src/tick/: lv_tick.c
  group lvgl/widgets
    ../third/lvgl/src/widgets/3dtexture/: lv_3dtexture.c
    ../third/lvgl/src/widgets/animimage/: lv_animimage.c
    ../third/lvgl/src/widgets/arc/: lv_arc.c
    ../third/lvgl/src/widgets/arclabel/: lv_arclabel.c
    ../third/lvgl/src/widgets/bar/: lv_bar.c
    ../third/lvgl/src/widgets/button/: lv_button.c
    ../third/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../third/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../third/lvgl/src/widgets/canvas/: lv_canvas.c
    ../third/lvgl/src/widgets/chart/: lv_chart.c
    ../third/lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../third/lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../third/lvgl/src/widgets/image/: lv_image.c
    ../third/lvgl/src/widgets/imagebutton/: lv_imagebutton.c
    ../third/lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../third/lvgl/src/widgets/label/: lv_label.c
    ../third/lvgl/src/widgets/led/: lv_led.c
    ../third/lvgl/src/widgets/line/: lv_line.c
    ../third/lvgl/src/widgets/list/: lv_list.c
    ../third/lvgl/src/widgets/lottie/: lv_lottie.c
    ../third/lvgl/src/widgets/menu/: lv_menu.c
    ../third/lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../third/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../third/lvgl/src/widgets/property/: lv_animimage_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_obj_properties.c lv_roller_properties.c lv_slider_properties.c lv_style_properties.c lv_textarea_properties.c
    ../third/lvgl/src/widgets/roller/: lv_roller.c
    ../third/lvgl/src/widgets/scale/: lv_scale.c
    ../third/lvgl/src/widgets/slider/: lv_slider.c
    ../third/lvgl/src/widgets/span/: lv_span.c
    ../third/lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../third/lvgl/src/widgets/spinner/: lv_spinner.c
    ../third/lvgl/src/widgets/switch/: lv_switch.c
    ../third/lvgl/src/widgets/table/: lv_table.c
    ../third/lvgl/src/widgets/tabview/: lv_tabview.c
    ../third/lvgl/src/widgets/textarea/: lv_textarea.c
    ../third/lvgl/src/widgets/tileview/: lv_tileview.c
    ../third/lvgl/src/widgets/win/: lv_win.c
  group filex/src
    ../third/filex/common/src/: fx_directory_attributes_read.c fx_directory_attributes_set.c fx_directory_create.c fx_directory_default_get.c fx_directory_default_get_copy.c fx_directory_default_set.c fx_directory_delete.c fx_directory_entry_read.c fx_directory_entry_write.c fx_directory_first_entry_find.c fx_directory_first_full_entry_find.c fx_directory_free_search.c fx_directory_information_get.c fx_directory_local_path_clear.c fx_directory_local_path_get.c fx_directory_local_path_get_copy.c fx_directory_local_path_restore.c fx_directory_local_path_set.c fx_directory_long_name_get.c fx_directory_long_name_get_extended.c fx_directory_name_extract.c fx_directory_name_test.c fx_directory_next_entry_find.c fx_directory_next_full_entry_find.c fx_directory_rename.c fx_directory_search.c fx_directory_short_name_get.c fx_directory_short_name_get_extended.c fx_fault_tolerant_add_FAT_log.c fx_fault_tolerant_add_bitmap_log.c fx_fault_tolerant_add_checksum_log.c fx_fault_tolerant_add_dir_log.c fx_fault_tolerant_apply_logs.c fx_fault_tolerant_calculate_checksum.c fx_fault_tolerant_cleanup_FAT_chain.c fx_fault_tolerant_create_log_file.c fx_fault_tolerant_enable.c fx_fault_tolerant_read_FAT.c fx_fault_tolerant_read_directory_sector.c fx_fault_tolerant_read_log_file.c fx_fault_tolerant_recover.c fx_fault_tolerant_reset_log_file.c fx_fault_tolerant_set_FAT_chain.c fx_fault_tolerant_transaction_end.c fx_fault_tolerant_transaction_fail.c fx_fault_tolerant_transaction_start.c fx_fault_tolerant_write_log_file.c fx_file_allocate.c fx_file_attributes_read.c fx_file_attributes_set.c fx_file_best_effort_allocate.c fx_file_close.c fx_file_create.c fx_file_date_time_set.c fx_file_delete.c fx_file_extended_allocate.c fx_file_extended_best_effort_allocate.c fx_file_extended_relative_seek.c fx_file_extended_seek.c fx_file_extended_truncate.c fx_file_extended_truncate_release.c fx_file_open.c fx_file_read.c fx_file_relative_seek.c fx_file_rename.c fx_file_seek.c fx_file_truncate.c fx_file_truncate_release.c fx_file_write.c fx_file_write_notify_set.c fx_media_abort.c fx_media_boot_info_extract.c fx_media_cache_invalidate.c fx_media_check.c fx_media_check_FAT_chain_check.c fx_media_check_lost_cluster_check.c fx_media_close.c fx_media_close_notify_set.c fx_media_extended_space_available.c fx_media_flush.c fx_media_format.c fx_media_format_oem_name_set.c fx_media_format_type_set.c fx_media_format_volume_id_set.c fx_media_open.c fx_media_open_notify_set.c fx_media_read.c fx_media_space_available.c fx_media_volume_get.c fx_media_volume_get_extended.c fx_media_volume_set.c fx_media_write.c fx_partition_offset_calculate.c fx_ram_driver.c fx_system_date_get.c fx_system_date_set.c fx_system_initialize.c fx_system_time_get.c fx_system_time_set.c fx_system_timer_entry.c fx_trace_event_insert.c fx_trace_event_update.c fx_trace_object_register.c fx_trace_object_unregister.c fx_utility_16_unsigned_read.c fx_utility_16_unsigned_write.c fx_utility_32_unsigned_read.c fx_utility_32_unsigned_write.c fx_utility_64_unsigned_read.c fx_utility_64_unsigned_write.c fx_utility_FAT_entry_read.c fx_utility_FAT_entry_write.c fx_utility_FAT_flush.c fx_utility_FAT_map_flush.c fx_utility_FAT_sector_get.c fx_utility_absolute_path_get.c fx_utility_logical_sector_cache_entry_read.c fx_utility_logical_sector_flush.c fx_utility_logical_sector_read.c fx_utility_logical_sector_write.c fx_utility_memory_copy.c fx_utility_memory_set.c fx_utility_string_length_get.c fx_utility_token_length_get.c
  group DAPLINK
    ../third/DAP/Source/: DAP.c DAP_vendor.c JTAG_DP.c SW_DP.c
software components: CMSIS:CORE 5.6.0
