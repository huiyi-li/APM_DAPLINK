# Keil uVision project apm32.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: APM32F407ZE Geehy
  pack: Geehy.APM32F4xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: apm32
  c flags: Optim=2 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: APM32F40X
  c include: ..\Libraries\Device\Geehy\APM32F4xx\Include;..\Libraries\APM32F4xx_StdPeriphDriver\inc;..\bsp\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group FWLib
    ../Libraries/APM32F4xx_StdPeriphDriver/src/: apm32f4xx_adc.c apm32f4xx_can.c apm32f4xx_comp.c apm32f4xx_crc.c apm32f4xx_cryp.c apm32f4xx_cryp_aes.c apm32f4xx_cryp_des.c apm32f4xx_cryp_tdes.c apm32f4xx_dac.c apm32f4xx_dbgmcu.c apm32f4xx_dci.c apm32f4xx_dma.c apm32f4xx_dmc.c apm32f4xx_eint.c apm32f4xx_fmc.c apm32f4xx_gpio.c apm32f4xx_hash.c apm32f4xx_hash_md5.c apm32f4xx_hash_sha1.c apm32f4xx_i2c.c apm32f4xx_iwdt.c apm32f4xx_misc.c apm32f4xx_pmu.c apm32f4xx_qspi.c apm32f4xx_rcm.c apm32f4xx_rng.c apm32f4xx_rtc.c apm32f4xx_sdio.c apm32f4xx_smc.c apm32f4xx_spi.c apm32f4xx_syscfg.c apm32f4xx_tmr.c apm32f4xx_usart.c apm32f4xx_usb.c apm32f4xx_usb_device.c apm32f4xx_usb_host.c apm32f4xx_wwdt.c
  group StartUp
    ../Libraries/Device/Geehy/APM32F4xx/Source/arm/: startup_apm32f40x.s
  group User
    ../User/: apm32f4xx_int.c main.c system_apm32f4xx.c
  group bsp
    ../bsp/src/: bsp_delay.c bsp_sdcard.c bsp_w25qxx.c
software components: CMSIS:CORE 5.6.0
